options:
  parameters:
    author: Antigravity
    description: Digital Television Modulation Playground simulating ATSC, DVB-S2, DVB-T, DVB-T2, and J.83B
    filename: /home/hunter/dtv_simulation.grc
    generate_options: qt_gui
    id: dtv_simulation
    output_language: python
    title: Digital Television Modulation Playground
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: noise_level
  id: variable_qtgui_range
  parameters:
    label: Channel Noise Voltage
    start: '0.0'
    step: '0.005'
    stop: '0.5'
    value: '0.0'
  states: {}
- name: active_standard
  id: variable_qtgui_chooser
  parameters:
    label: DTV Standard
    label0: ATSC (8VSB / 8-PAM)
    label1: DVB-S2 (8-PSK)
    label2: ITU-T J.83B (64-QAM)
    label3: DVB-T2 (Rotated 64-QAM)
    label4: DVB-T (OFDM - QPSK)
    num_opts: '5'
    option0: '0'
    option1: '1'
    option2: '2'
    option3: '3'
    option4: '4'
    options: '[0, 1, 2, 3, 4]'
    type: int
    value: '0'
  states: {}
- name: tx_path_select
  id: variable
  parameters:
    value: 0 if active_standard < 2 else 1 if active_standard < 4 else 2
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: '0.0'
  states: {}
- name: timing_offset
  id: variable
  parameters:
    value: '1.0'
  states: {}
- name: multipath_gain
  id: variable
  parameters:
    value: '0.0'
  states: {}
- name: atsc_points
  id: variable
  parameters:
    value: '[-7, -5, -3, -1, 1, 3, 5, 7]'
  states: {}
- name: dvbs2_points
  id: variable
  parameters:
    value: '[1+0j, 0.707+0.707j, 0+1j, -0.707+0.707j, -1+0j, -0.707-0.707j, 0-1j, 0.707-0.707j]'
  states: {}
- name: j83b_points
  id: variable
  parameters:
    value: '[complex(x, y) for x in [-7,-5,-3,-1,1,3,5,7] for y in [-7,-5,-3,-1,1,3,5,7]]'
  states: {}
- name: dvbt2_points
  id: variable
  parameters:
    value: '[complex(x, y) * (0.8746 + 0.4848j) for x in [-7,-5,-3,-1,1,3,5,7] for y in [-7,-5,-3,-1,1,3,5,7]]'
  states: {}
- name: const_points_choice
  id: variable
  parameters:
    value: '[atsc_points, dvbs2_points, j83b_points, dvbt2_points][active_standard if active_standard < 4 else 0]'
  states: {}
- name: atsc_const
  id: variable_constellation
  parameters:
    const_points: atsc_points
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '2'
    sym_map: '[0, 1, 2, 3, 4, 5, 6, 7]'
    type: calcdist
  states: {}
- name: dvbs2_const
  id: variable_constellation
  parameters:
    const_points: '[]'
    precision: '8'
    sym_map: '[0, 1, 2, 3, 4, 5, 6, 7]'
    type: 8psk
  states: {}
- name: j83b_const
  id: variable_constellation
  parameters:
    const_points: j83b_points
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: list(range(64))
    type: calcdist
  states: {}
- name: dvbt2_const
  id: variable_constellation
  parameters:
    const_points: dvbt2_points
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: list(range(64))
    type: calcdist
  states: {}
- name: const_choice
  id: variable
  parameters:
    value: '[atsc_const, dvbs2_const, j83b_const, dvbt2_const][active_standard if active_standard < 4 else 0]'
  states: {}
- name: udp_source
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    payloadsize: '1470'
    port: '5001'
    src_zeros: 'False'
    type: byte
  states: {}
- name: tx_selector
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '3'
    output_index: tx_path_select
    type: byte
  states: {}
- name: unpack_8_p1
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: pack_3_p1
  id: blocks_pack_k_bits_bb
  parameters:
    k: '3'
  states: {}
- name: map_symbols_p1
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: const_points_choice
  states: {}
- name: unpack_8_p2
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: pack_6_p2
  id: blocks_pack_k_bits_bb
  parameters:
    k: '6'
  states: {}
- name: map_symbols_p2
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: const_points_choice
  states: {}
- name: stream_to_tagged_p3
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '1470'
    type: byte
  states: {}
- name: ofdm_tx_p3
  id: digital_ofdm_tx
  parameters:
    cp_len: '16'
    fft_len: '64'
    header_mod: '"BPSK"'
    occupied_carriers: ([-26, -25, -24, -23, -22, -20, -19, -18, -17, -16, -15, -14, -13, -12, -11, -10, -9, -8, -6, -5, -4, -3, -2, -1, 1, 2, 3, 4, 5, 6, 8, 9, 10, 11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 22, 23, 24, 25, 26],)
    packet_len_key: '"packet_len"'
    payload_mod: '"QPSK"'
    pilot_carriers: ((-21, -7, 7, 21),)
    pilot_symbols: ((1, 1, 1, -1),) * 127
    rolloff: '0'
    scramble_bits: 'True'
    sync_word1: None
    sync_word2: None
  states: {}
- name: tx_rf_selector
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: tx_path_select
    num_inputs: '3'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: rf_throttle
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: channel_model
  id: channels_channel_model
  parameters:
    epsilon: timing_offset
    freq_offset: freq_offset
    noise_voltage: noise_level
    seed: '0'
    taps: '[1.0, 0.0, multipath_gain]'
  states: {}
- name: rf_spectrum
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '512'
    grid: 'True'
    label1: RF Spectrum
    type: complex
    update_time: '0.05'
    yunits: dB
  states: {}
- name: rf_constellation
  id: qtgui_constellation_sink_x
  parameters:
    alpha1: '1.0'
    alpha2: '1.0'
    autoscale: 'False'
    axislabels: 'True'
    color1: '"blue"'
    color2: '"red"'
    grid: 'True'
    label1: RF Constellation
    label2: ''
    legend: 'True'
    marker1: '0'
    marker2: '0'
    name: '""'
    nconnections: '1'
    size: '1024'
    style1: '0'
    style2: '0'
    tr_chan: '0'
    tr_level: '0.0'
    tr_mode: qtgui.TRIG_MODE_FREE
    type: complex
    update_time: '0.05'
    xmax: '9'
    xmin: '-9'
    ymax: '9'
    ymin: '-9'
  states: {}
- name: rx_rf_selector
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '3'
    output_index: tx_path_select
    type: complex
  states: {}
- name: decode_symbols_p1
  id: digital_constellation_decoder_cb
  parameters:
    constellation: const_choice
  states: {}
- name: unpack_3_p1
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '3'
  states: {}
- name: pack_8_p1
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: decode_symbols_p2
  id: digital_constellation_decoder_cb
  parameters:
    constellation: const_choice
  states: {}
- name: unpack_6_p2
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '6'
  states: {}
- name: pack_8_p2
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: ofdm_rx_p3
  id: digital_ofdm_rx
  parameters:
    cp_len: '16'
    fft_len: '64'
    header_mod: '"BPSK"'
    occupied_carriers: ([-26, -25, -24, -23, -22, -20, -19, -18, -17, -16, -15, -14, -13, -12, -11, -10, -9, -8, -6, -5, -4, -3, -2, -1, 1, 2, 3, 4, 5, 6, 8, 9, 10, 11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 22, 23, 24, 25, 26],)
    packet_len_key: '"packet_len"'
    payload_mod: '"QPSK"'
    pilot_carriers: ((-21, -7, 7, 21),)
    pilot_symbols: ((1, 1, 1, -1),) * 127
    scramble_bits: 'True'
    sync_word1: None
    sync_word2: None
  states: {}
- name: rx_byte_selector
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: tx_path_select
    num_inputs: '3'
    num_outputs: '1'
    output_index: '0'
    type: byte
  states: {}
- name: udp_sink
  id: network_udp_sink
  parameters:
    host: 127.0.0.1
    ipv6: 'False'
    payloadsize: '1470'
    port: '5002'
    send_eof: 'False'
    type: byte
  states: {}

connections:
- [udp_source, '0', tx_selector, '0']
- [tx_selector, '0', unpack_8_p1, '0']
- [tx_selector, '1', unpack_8_p2, '0']
- [tx_selector, '2', stream_to_tagged_p3, '0']
- [unpack_8_p1, '0', pack_3_p1, '0']
- [pack_3_p1, '0', map_symbols_p1, '0']
- [unpack_8_p2, '0', pack_6_p2, '0']
- [pack_6_p2, '0', map_symbols_p2, '0']
- [stream_to_tagged_p3, '0', ofdm_tx_p3, '0']
- [map_symbols_p1, '0', tx_rf_selector, '0']
- [map_symbols_p2, '0', tx_rf_selector, '1']
- [ofdm_tx_p3, '0', tx_rf_selector, '2']
- [tx_rf_selector, '0', rf_throttle, '0']
- [rf_throttle, '0', channel_model, '0']
- [channel_model, '0', rf_spectrum, '0']
- [channel_model, '0', rf_constellation, '0']
- [channel_model, '0', rx_rf_selector, '0']
- [rx_rf_selector, '0', decode_symbols_p1, '0']
- [rx_rf_selector, '1', decode_symbols_p2, '0']
- [rx_rf_selector, '2', ofdm_rx_p3, '0']
- [decode_symbols_p1, '0', unpack_3_p1, '0']
- [unpack_3_p1, '0', pack_8_p1, '0']
- [decode_symbols_p2, '0', unpack_6_p2, '0']
- [unpack_6_p2, '0', pack_8_p2, '0']
- [pack_8_p1, '0', rx_byte_selector, '0']
- [pack_8_p2, '0', rx_byte_selector, '1']
- [ofdm_rx_p3, '0', rx_byte_selector, '2']
- [rx_byte_selector, '0', udp_sink, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
